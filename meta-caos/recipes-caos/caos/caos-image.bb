SUMMARY = "simple caos files"

DEPENDS+="caos"

IMAGE_INSTALL = "caos"

IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit core-image